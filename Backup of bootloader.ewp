# IAR project Backup of bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: link.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c serial.c
